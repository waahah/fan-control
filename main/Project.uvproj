# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Key.c Key.h Nixie.c Nixie.h Timer1.c Timer1.h Motor.c Motor.h Int0.c Int0.h Timer0.c Timer0.h IR.c IR.h AT24C02.c AT24C02.h LCD1602.c LCD1602.h DS18B20.c DS18B20.h OneWire.c OneWire.h I2C.c I2C.h Buzzer.c Buzzer.h MatrixKey.c MatrixKey.h
